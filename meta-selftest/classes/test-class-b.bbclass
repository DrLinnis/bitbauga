inherit test-class-a