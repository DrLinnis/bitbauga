inherit test-class-c