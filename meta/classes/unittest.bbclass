inherit base

# This class should have both `native` and `target` versions.
