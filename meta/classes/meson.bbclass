inherit base