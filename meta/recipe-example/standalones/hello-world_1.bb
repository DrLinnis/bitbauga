inherit meson

include debug.inc
require unittest
