inherit base cmake

include debug.inc
require unit-tests
